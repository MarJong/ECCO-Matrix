# Repository MarJong/ECCO-Matrix

File README.md:

# ECCO-Matrix
Archiv der Daten zum LED Matrix Ausstellungsstück des Elektronik Club Cottbus (ECCO)

## KiCad design Hardware/matrix - master.kicad_pcb

Parts:
5V: Batterie
C1, C2: 22p
C3, C6, C7, C8, C10, C11, C18: 100n
C4, C17: 1µ
C5, C9, C16, C19, C20: 10µ
C12, C15: 10n
C13, C14: 220n
C21, C22: 50n
C23, C24: 250µ
CON1: AVR-ISP-6V2; AVR-ISP-6
F1, F2: FUSE
IC1: ATMEGA644-P; DIL40
P1: CONN_POWER
P2: slave data
P3: PS2 Controller
P4: LCD
P5: Audio Poti
P6: CONN_RELAIS
P7: Speaker Rechts
P8: Speaker Links
Q1: BD139; TO126
R1, R2: 10k
R3, R4: 1,2k
R5, R6, R9: 1k
R7, R8: 10
R10, R11: 100k
RV1: 10k
SW1: SW_PUSH
U1, U4: LM386
U2: 74HCT595
U3: ULN2803
X1: 20MHz

Connections:
+5V: 5V.1 (+), C6.2, C7.2, C8.2, C10.1, C16.1, C17.1, C18.2, CON1.2, F1.1, IC1.10 (VCC), IC1.30 (AVCC), P3.1, P4.2, R1.1, R2.1, U1.6 (Pwr), U2.16 (Vcc), U3.10 (Common), U4.6 (Pwr)
/5V_2: C9.1, F2.1, P3.3, P4.19
/5V_INPUT: C4.1, C5.1, F1.2, F2.2, P1.4
/AUDIO_L: C13.1, P5.6
/AUDIO_OUT_L: IC1.34 ((PCINT6/ADC6)PA6), R9.1
/AUDIO_OUT_R: IC1.33 ((PCINT7/ADC7)PA7), R6.1
/AUDIO_R: C14.2, P5.5
/D0: IC1.1 ((PCINT8/T0/XCK)PB0), P4.7
/D1: IC1.2 ((PCINT9/CLKO/T1)PB1), P4.8
/D2: IC1.3 ((PCINT10/AIN0/INT2)PB2), P4.9
/D3: IC1.4 ((PCINT11/AIN1/OC0A)PB3), P4.10
/D4: IC1.5 ((PCINT12/OC0B/~SS~)PB4), P4.11
/D5: CON1.4, IC1.6 ((PCINT13/MOSI)PB5), P4.12
/D6: CON1.1, IC1.7 ((PCINT14/MISO)PB6), P4.13
/D7: CON1.3, IC1.8 ((PCINT15/SCK)PB7), P4.14
/LCD_CS1: IC1.39 ((PCINT1/ADC1)PA1), P4.15
/LCD_CS2: IC1.40 ((PCINT0/ADC0)PA0), P4.16
/LCD_E: IC1.38 ((PCINT2/ADC2)PA2), P4.6
/LCD_LIGHT: IC1.25 ((PCINT19/TMS)PC3), R5.1
/LCD_RESET: IC1.35 ((PCINT5/ADC5)PA5), P4.17
/LCD_RS: IC1.36 ((PCINT4/ADC4)PA4), P4.4
/LCD_RW: IC1.37 ((PCINT3/ADC3)PA3), P4.5
/PS2_ATT: IC1.26 ((PCINT20/TDO)PC4), P3.7
/PS2_CLK: IC1.29 ((PCINT23/TOSC2)PC7), P3.4
/PS2_CMD: IC1.27 ((PCINT21/TDI)PC5), P3.6
/PS2_DATA: IC1.28 ((PCINT22/TOSC1)PC6), P3.5
/RESET: CON1.5, IC1.9 (~RESET), R1.2, SW1.2
/SR_CLK: IC1.24 ((PCINT18/TCK)PC2), U2.11 (SCLK)
/SR_DATA: IC1.22 ((PCINT16/SCL)PC0), U2.14 (Sin)
/SR_LATCH: IC1.23 ((PCINT17/SDA)PC1), U2.12 (LATCH)
/SR_OUTEN: IC1.21 ((PCINT31/OC2A)PD7), U2.13 (OE)
/V0: C11.1, P4.3, RV1.2
/Vee: P4.18, RV1.3
/mRX: IC1.14 ((PCINT24/RXD0)PD0), P2.1
/mTX: IC1.15 ((PCINT25/TXD0)PD1), P2.2
/slaveCS1: IC1.16 ((PCINT26/INT0)PD2), P2.3
/slaveCS2: IC1.17 ((PCINT27/INT1)PD3), P2.4
/slaveCS3: IC1.18 ((PCINT28/OC1B)PD4), P2.5
/slaveCS4: IC1.19 ((PCINT294/OC1A)PD5), P2.6
/slaveCS5: IC1.20 ((PCINT30/OC2B/ICP)PD6), P2.7
GND: C1.1, C2.1, C3.1, C4.2, C5.2, C6.1, C7.1, C8.1, C9.2, C10.2, C11.2, C12.1, C15.1, C16.2, C17.2, C18.1, CON1.6, IC1.11 (GND), IC1.31 (GND), P1.3, P3.2, P4.1, P5.3, P5.4, P7.2 (PM), P8.2 (PM), Q1.1 (E), R7.2, R8.2, R10.2, R11.2, RV1.1, SW1.1, U1.2 (-), U1.4 (Gnd), U2.8 (GND), U3.9 (GND), U4.2 (-), U4.4 (Gnd)
unnamed: C15.2, P5.2, R9.2
unnamed: P4.20, Q1.2 (C)
unnamed: U2.4 (O5), U3.4 (IN4)
unnamed: R2.2, U2.10 (MR)
unnamed: U2.7 (O8), U3.1 (IN1)
unnamed: U2.6 (O7), U3.2 (IN2)
unnamed: U2.5 (O6), U3.3 (IN3)
unnamed: U2.3 (O4), U3.5 (IN5)
unnamed: U2.2 (O3), U3.6 (IN6)
unnamed: U2.1 (O2), U3.7 (IN7)
unnamed: U2.15 (O1), U3.8 (IN8)
unnamed: P6.3, U3.16 (OUT3)
unnamed: P6.8, U3.11 (OUT8)
unnamed: P6.7, U3.12 (OUT7)
unnamed: P6.6, U3.13 (OUT6)
unnamed: P6.5, U3.14 (OUT5)
unnamed: P6.4, U3.15 (OUT4)
unnamed: P6.2, U3.17 (OUT2)
unnamed: P6.1, U3.18 (OUT1)
unnamed: C21.1, C23.1, U1.5
unnamed: C21.2, R7.1
unnamed: C20.2, U4.8 (Gain)
unnamed: C20.1, R4.2
unnamed: R4.1, U4.1 (Gain)
unnamed: R3.1, U1.1 (Gain)
unnamed: C19.2, U1.8 (Gain)
unnamed: C14.1, R10.1, U1.3 (+)
unnamed: C23.2, P7.1
unnamed: C19.1, R3.2
unnamed: C13.2, R11.1, U4.3 (+)
unnamed: C12.2, P5.1, R6.2
unnamed: C22.2, R8.1
unnamed: C24.2, P8.1
unnamed: C22.1, C24.1, U4.5
unnamed: Q1.3 (B), R5.2
unnamed: C3.2, IC1.32 (AREF)
unnamed: C2.2, IC1.13 (XTAL1), X1.1
unnamed: C1.2, IC1.12 (XTAL2), X1.2

Notes on the sheet:
Controller
Versorgung
Slave Anschluss
PS2 Controller
Relaisansteuerung
LCD Ansteuerung
ISP Anschluss
15,9kHz TP
Audioverstärker

Board: 2 copper layers, 100.3 x 160.0 mm, 55 parts (0 on the bottom side), 79 nets.

## KiCad design Hardware/matrix - stromanschluss.kicad_pcb

Parts:
P1: CONN_10X2
P2: CONN_5
P3: Switch
P4: CONN_1

Connections:
+3.3V: P1.17, P1.19, P1.20, P2.5
+5V: P1.2, P1.4, P1.9, P1.13, P2.3
+12V: P1.1, P2.1
-12V: P1.18, P2.4
/PS_ON: P1.14, P3.1
GND: P1.7, P1.8, P1.10, P1.11, P1.12, P1.15, P1.16, P2.2, P3.2 (PM)

Board: 2 copper layers, 4 parts (0 on the bottom side), 6 nets.

## KiCad design Hardware/matrix - slave.kicad_pcb

Board: 2 copper layers, 99.1 x 42.7 mm, 23 parts (0 on the bottom side), 46 nets.

Parts:
C1: 100µ; C1V8
C2: 22µ; C1V8
C3, C4: 22p; C1
C5, C6, C7: 100n; C1
IC1: ATTINY2313-P; DIP-20__300_ELL
K1: CONN_3; SIL-3
P1: CONN_2; SIL-2
P2, P3, P4, P5, P6: CONN_4; SIL-4
R1, R2, R3: 10k; R4
U1, U2: 74HCT595; DIP-16__300_ELL
U3, U4: ULN2803; DIP-18__300_ELL
X1: 20MHz; HC-49V

Connections:
+5V: C1.1, C2.1, C5.1, C6.2, C7.2, IC1.20, P1.2, P2.1, P3.1, P4.1, P5.1, P6.1, R1.1, R2.1, R3.1, U1.16, U2.16, U3.10, U4.10
/CLK: IC1.19, U1.11, U2.11
/CS: IC1.6, K1.1
/DO: IC1.18, U1.14
/ENABLE: IC1.15, U1.13, U2.13
/LATCH: IC1.16, U1.12, U2.12
/RESET: IC1.1, R1.2
/sRX: IC1.2, K1.3
/sTX: IC1.3, K1.2
GND: C1.2, C2.2, C3.1, C4.1, C5.2, C6.1, C7.1, IC1.10, P1.1, U1.8, U2.8, U3.9, U4.9
unnamed: P2.2, U3.17
unnamed: P2.4, U3.15
unnamed: P3.3, U3.13
unnamed: U2.15, U4.8
unnamed: P6.4, U4.11
unnamed: P4.2, U3.11
unnamed: P4.4, U4.17
unnamed: P5.3, U4.15
unnamed: P5.4, U4.14
unnamed: P6.3, U4.12
unnamed: U1.4, U3.4
unnamed: R2.2, U1.10
unnamed: U1.9, U2.14
unnamed: U1.7, U3.1
unnamed: U1.6, U3.2
unnamed: U1.5, U3.3
unnamed: U1.15, U3.8
unnamed: U1.3, U3.5
unnamed: U1.2, U3.6
unnamed: U1.1, U3.7
unnamed: R3.2, U2.10
unnamed: C3.2, IC1.4, X1.2
unnamed: C4.2, IC1.5, X1.1
unnamed: U2.7, U4.1
unnamed: U2.6, U4.2
unnamed: U2.5, U4.3
unnamed: U2.4, U4.4
unnamed: U2.3, U4.5
unnamed: U2.2, U4.6
unnamed: U2.1, U4.7
unnamed: P6.2, U4.13
unnamed: P5.2, U4.16
unnamed: P3.2, U3.14
unnamed: P2.3, U3.16
unnamed: P3.4, U3.12
unnamed: P4.3, U4.18

## Code that names these connections

File Firmware - Master/ECCO Matrix - Master/master.h:

/*
	Port Definitionen
	Allgemeine Hilfsfunktionen
*/

#ifndef MASTER_H_
#define MASTER_H_

#define STATE_TIMEOUT_LEN		180000UL		// nach x msek wieder idle

#define nop				asm volatile ("nop")

#define sbi(x, y)		((x) |= (y))
#define cbi(x, y)		((x) &= ~(y))
#define isset(x, y)		((x) & (y))

// Schieberegister für Relais
#define SR_PORT			PORTC
#define SR_LATCH		PC1
#define SR_CLOCK		PC2
#define SR_DATA			PC0
//outputenable portd pd7

// PS2 Controller
#define PS2_PORT		PORTC
#define PS2_PIN			PINC
#define PS2_ATT			PC4
#define PS2_CMD			PC5
#define PS2_DATA		PC6
#define PS2_CLOCK		PC7

// LCD - Daten
#define LCD_DATA		PORTB
#define LCD_DATA_PIN	PINB
// LCD - Steuerung
#define LCD_PORT		PORTA
#define LCD_CS2			PA0
#define LCD_CS1			PA1
#define LCD_E			PA2
#define LCD_RW			PA3
#define LCD_RS			PA4
#define LCD_RESET		PA5
// beleuchtung portc pc3

// Audio
#define AUDIO_PORT		PORTA
#define AUDIO_LEFT		PA6
#define AUDIO_RIGHT		PA7

// Slaves -> usart.h

// flags
#define FLAG_UPDATE_FRAME		0x01		// update für bild/led (berechnen)
#define FLAG_TIMER_TICK			0x02		// 10Hz timer
#define FLAG_PS2INPUT_TICK		0x04		// controller auslesen
#define FLAG_AUDIO_TICK			0x08		// audiokram
#define FLAG_TRANSFER_FRAME		0x10		// neues bild übertragen
#define FLAG_SCROLL_TEXT		0x20		// lauftext läuft
#define FLAG_IDLE_AND_LCD		0x40		// idle state mit lcd backlight an
#define FLAG_REDRAW_GECCO		0x80		// ecco logo neu zeichnen

// state
#define STATE_IDLE				1			// idle modus; zufällige animationen abspielen
#define STATE_UI_MATRIX			2			// interaktion mit matrix/schaukästen
#define STATE_UI_MENU			3			// interaktion mit lcd/menü
#define STATE_APP				4			// APP!

// globale variablen

extern volatile uint32_t timestamp;

#endif /* MASTER_H_ */

File Firmware - Slave/ECCO Matrix - Slave/slave.h:

/*
 * slave.h
 *
 * Created: 20.06.2013 19:14:54
 *  Author: Marcel
 */ 

#ifndef SLAVE_H_
#define SLAVE_H_

#define FLAG_UPDATE		0x01		// eingangs -> ausgabebuffer
#define FLAG_EXECUTE	0x02		// usart befehl ausführen
#define FLAG_OUTPUT		0x04		// led daten in shift register
#define FLAG_TIME		0x08		// viel freizeit für usart

#define nop				asm volatile ("nop")

#define sbi(port, pin)		((port) |= (1 << (pin)))
#define cbi(port, pin)		((port) &= ~(1 << (pin)))

// schieberegister anschluss
#define SR_PORT			PORTB
#define SR_CLK			PB7
#define SR_DO			PB6
#define SR_LATCH		PB4
#define SR_ENABLE		PB3

#define ENABLE_RX		(UCSRB |=  ((1 << RXCIE) | (1 << RXEN)))
#define DISABLE_RX		(UCSRB &= ~((1 << RXCIE) | (1 << RXEN)))

#define USART_BUFFER_LEN		32

// befehle
#define CMD_ALL_RGB				0x10
#define CMD_ROW_RGB				0x11
#define CMD_FIELD_RGB			0x12

#define CMD_LATCH				0x20

#define CMD_DISABLE				0x30
#define CMD_ENABLE				0x31

#define USART_NEXT_CMD			0xF0
#define USART_EXECUTE			0xFE

#define RESP_ACK				0xAA

// länge kürzester pwm cycle
#define TIMER_BASE_OCR			783

// sonstiges
typedef struct 
{
	uint8_t r, g, b;
} led_data_t;

#endif /* SLAVE_H_ */

File Firmware - Master/ECCO Matrix - Master/usart.h:

#ifndef USART_H_
#define USART_H_

#include "led.h"

#define sCSall_ON	(PORTD &= ~((1 << PD2) | (1 << PD3) | (1 << PD4) | (1 << PD5) | (1 << PD6)))
#define sCSall_OFF	(PORTD |= ((1 << PD2) | (1 << PD3) | (1 << PD4) | (1 << PD5) | (1 << PD6)))

#define USART_CMD_SETCOL		0x10
#define USART_CMD_LATCH			0x20
#define USART_CMD_ON			0x30
#define USART_CMD_OFF			0x31
#define USART_CMD_SYNC			0xF0
#define USART_CMD_END			0xFE
#define USART_CMD_ACK			0xAA

// init
void usart_init(void);

// data schicken + warten bis fertig
void usart_send(uint8_t data);
// warten falls nötig + schicken
void usart_send2(uint8_t data);

// schickt komplettes led_data paket
void usart_send_led_data();

#endif /* USART_H_ */

## Commit log

2023-09-17 Archivierung
2023-09-17 Create LICENSE
